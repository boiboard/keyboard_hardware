File: core/ledchain0.sch (KiCad schematic (older format))
At the start: 60 parts, among them U2 WS2811

Commit message: annotate led chain
Parts:
- gave numbers to parts that had none: 58
